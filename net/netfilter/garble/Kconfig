## net/netfilter/nf_dnslisten/Kconfig
```kconfig
config NF_DNSLISTEN
	tristate "DNS listening based on cgroup net_cls"
	default y
```
